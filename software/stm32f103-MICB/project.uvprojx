# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32F103xE
  c include: applications;applications\inc;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;packages\crclib-v1.02\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\hwcrypto;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;packages\fal-v1.0.0\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;packages\FlashDB-v1.1.2\inc;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;libraries\STM32F1xx_HAL\CMSIS\Include;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\socket\sys_socket;packages\wiznet-latest\inc;packages\wiznet-latest\ioLibrary;packages\wiznet-latest\ioLibrary\Ethernet;packages\wiznet-latest\ioLibrary\Internet
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/src/: main.c AP_ctrl.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group crclib
    packages/crclib-v1.02/src/: crc8.c crc32.c crc16_ex_sample.c crc32_ex.c crc16.c crc16_ex.c crc8_ex.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwcrypto/: hwcrypto.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: dataqueue.c ringbuffer.c completion.c ringblk_buf.c workqueue.c waitqueue.c pipe.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_gpio.c drv_can.c drv_rtc.c drv_spi.c drv_wdt.c drv_crypto.c drv_usart.c drv_common.c drv_adc.c drv_hwtimer.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f1.c
  group fal
    packages/fal-v1.0.0/src/: fal_partition.c fal_flash.c fal_rtt.c fal.c
    packages/fal-v1.0.0/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group FlashDB
    packages/FlashDB-v1.1.2/src/: fdb_kvdb.c fdb_utils.c fdb_tsdb.c fdb_cmd.c fdb_file.c fdb.c
  group Kernel
    rt-thread/src/: ipc.c irq.c kservice.c scheduler.c mem.c timer.c idle.c mempool.c components.c thread.c device.c object.c clock.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: stdio.c libc.c syscalls.c mem_std.c
    rt-thread/components/libc/compilers/common/: delay.c unistd.c time.c stdlib.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_tim.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_i2c.c stm32f1xx_hal_eth.c stm32f1xx_hal_rcc_ex.c stm32f1xx_ll_spi.c stm32f1xx_hal_rtc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_wwdg.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group WIZnet
    packages/wiznet-latest/src/: wiz.c wiz_ping.c wiz_device.c wiz_af_inet.c wiz_socket.c
    packages/wiznet-latest/ioLibrary/Ethernet/W5500/: w5500.c
    packages/wiznet-latest/ioLibrary/Ethernet/: wizchip_socket.c wizchip_conf.c
    packages/wiznet-latest/ioLibrary/Internet/DNS/: wizchip_dns.c
